/**
 * =============================================================
* @file        DataManager.cpp
 * @author      kinketsu patron (https://kinketsu-patron.com)
 * @brief       データ入出力管理
 * @version     1.0
 * @date        2024-06-08
 * =============================================================
 */

// =======================================================
// ヘッダインクルード
// =======================================================
#include "inc/DataManager.h"

// =======================================================
// 静的変数
// =======================================================
static uint32 mIN_Coin;
static uint32 mOUT_Coin;
static uint32 mRB;
static uint32 mBB;

/**
 * =======================================================
 * @fn          Data_Init
 * @brief       データ管理の初期化を行う
 * @date        2024-06-10
 * =======================================================
 */
void Data_Init( void )
{
        mIN_Coin  = 0U;
        mOUT_Coin = 0U;
        mRB       = 0U;
        mBB       = 0U;
}

/**
 * =======================================================
 * @fn          Get_IN_Coin
 * @brief       入力枚数を取得する
 * @date        2024-06-10
 * =======================================================
 */
uint32 Get_IN_Coin ( void ) { return mIN_Coin; }

/**
 * =======================================================
 * @fn          Get_OUT_Coin
 * @brief       出力枚数を取得する
 * @date        2024-06-10
 * =======================================================
 */
uint32 Get_OUT_Coin( void ) { return mOUT_Coin; }

/**
 * =======================================================
 * @fn          Get_RB
 * @brief       レギュラーボーナス回数を取得する
 * @date        2024-06-10
 * =======================================================
 */
uint32 Get_RB ( void ) { return mRB; }

/**
 * =======================================================
 * @fn          Get_BB
 * @brief       ビッグボーナス回数を取得する
 * @date        2024-06-10
 * =======================================================
 */
uint32 Get_BB ( void ) { return mBB; }

/**
 * =======================================================
 * @fn          Set_IN_Coin
 * @brief       入力枚数を設定する
 * @date        2024-06-10
 * =======================================================
 */
void Set_IN_Coin( uint32 pIN_Coin )
{
        if ( pIN_Coin >= 0U )
        {
                mIN_Coin = pIN_Coin;
        }
}

/**
 * =======================================================
 * @fn          Set_OUT_Coin
 * @brief       出力枚数を設定する
 * @date        2024-06-10
 * =======================================================
 */
void Set_OUT_Coin( uint32 pOUT_Coin )
{
        if ( pOUT_Coin >= 0U )
        {
                mOUT_Coin = pOUT_Coin;
        }
}

/**
 * =======================================================
 * @fn          Set_RB
 * @brief       レギュラーボーナス回数を設定する
 * @date        2024-06-10
 * =======================================================
 */
void Set_RB( uint32 pRB )
{
        if ( pRB >= 0U )
        {
                mRB = pRB;
        }
}

/**
 * =======================================================
 * @fn          Set_BB
 * @brief       ビッグボーナス回数を設定する
 * @date        2024-06-10
 * =======================================================
 */
void Set_BB( uint32 pBB )
{
        if ( pBB >= 0U )
        {
                mBB = pBB;
        }
}